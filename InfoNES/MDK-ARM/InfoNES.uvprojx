# Keil uVision project InfoNES.uvprojx, settings and files
target InfoNES (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: InfoNES +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\KEY;..\HARDWARE\ST7789;..\HARDWARE\TIMER;..\HARDWARE\UART;..\HARDWARE\W25QXX;..\HARDWARE\WAV;..\HARDWARE\MENU;..\HARDWARE\CALENDAR;..\HARDWARE\IN_FLASH;..\HARDWARE\GAME;..\HARDWARE\NES;..\HARDWARE\NES\mapper;..\HARDWARE\FatFs;..\HARDWARE\FatFs\option;..\HARDWARE\JPEG;..\HARDWARE\JPEG\TjpgDec;..\..\InfoNES
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: InfoNES\InfoNES.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group work
    ../: my_main.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ST7789/: st7789.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WAV/: wav.c
    ../HARDWARE/MENU/: menu.c
    ../HARDWARE/CALENDAR/: calendar.c
    ../HARDWARE/IN_FLASH/: in_flash.c
    ../HARDWARE/GAME/: game.c
  group nes
    ../HARDWARE/NES/: nes_apu.c nes_main.c nes_mapper.c nes_ppu.c 6502.s
  group Fatfs
    ../HARDWARE/FatFs/: diskio.c fatfs.c ff.c ffsystem.c ffunicode.c
  group jpeg
    ../HARDWARE/JPEG/: jpeg.c
    ../HARDWARE/JPEG/TjpgDec/: tjpgd.c
software components: CMSIS:CORE 4.3.0
